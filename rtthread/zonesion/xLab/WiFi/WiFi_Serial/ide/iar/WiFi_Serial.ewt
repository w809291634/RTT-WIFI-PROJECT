<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>rtthread</name>
    <group>
      <name>libcpu</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\libcpu\arm\cortex-m4\context_iar.S</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\libcpu\arm\cortex-m4\cpuport.c</name>
      </file>
    </group>
    <group>
      <name>module</name>
      <group>
        <name>finsh</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\cmd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_compiler.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_error.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_heap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_node.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_ops.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_parser.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_token.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_var.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\finsh_vm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\msh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\msh_file.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\shell.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\finsh\symbol.c</name>
        </file>
      </group>
      <group>
        <name>ringbuffer</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\drivers\src\ringbuffer.c</name>
        </file>
      </group>
      <group>
        <name>uip</name>
        <group>
          <name>apps</name>
          <group>
            <name>dhcpc</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\dhcpc\dhcpc.c</name>
            </file>
          </group>
          <group>
            <name>resolv</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\resolv\resolv.c</name>
            </file>
          </group>
          <group>
            <name>smtp</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\smtp\smtp-strings.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\smtp\smtp.c</name>
            </file>
          </group>
          <group>
            <name>telnetd</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\telnetd\telnetd.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\telnetd\uip_shell.c</name>
            </file>
          </group>
          <group>
            <name>webclient</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webclient\webclient-strings.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webclient\webclient.c</name>
            </file>
          </group>
          <group>
            <name>webserver</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webserver\http-strings.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webserver\httpd-cgi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webserver\httpd-fs.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webserver\httpd-fsdata.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\apps\webserver\httpd.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>uip_dev</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\unix\clock-arch.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\unix\tapdev.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\unix\uip-conf.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\psock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uip-fw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uip-neighbor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uip-split.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uip_arp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uip_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\components\net\uip\uip\uiplib.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\components.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\cpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\idle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\ipc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\irq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\kservice.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\memheap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\mempool.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\scheduler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\signal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\slab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\thread.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\src\timer.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\src\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\rtconfig.h</name>
    </file>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>app</name>
      <group>
        <name>sensor</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\sensor\sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\sensor\sensor_thread.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\src\finsh_cmd\finsh_ex.c</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <group>
        <name>APL</name>
        <group>
          <name>apl_at</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_at\at_app.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_at\at_hw.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_at\at_thread.c</name>
          </file>
        </group>
        <group>
          <name>apl_rf</name>
          <group>
            <name>wifi</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\Common\APL\apl_rf\wifi\wifi_drv.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_rf\rf_if_app.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_rf\rf_if_hw.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_rf\rf_thread.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Common\APL\apl_rf\zxbee\zxbee.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>BSP</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Common\BSP\bsp_flash\flash.c</name>
        </file>
      </group>
      <group>
        <name>DEV</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Common\DEV\dev_serial\serial.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Common\DEV\dev_uart\usart.c</name>
        </file>
      </group>
      <group>
        <name>DRV</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Common\DRV\drv_led\fml_led.c</name>
        </file>
      </group>
      <group>
        <name>LIB</name>
        <group>
          <name>stm32f10x</name>
          <group>
            <name>cmsis</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\CMSIS\CM3\CoreSupport\core_cm3.c</name>
            </file>
          </group>
          <group>
            <name>fwlib</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\misc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
            </file>
          </group>
          <group>
            <name>startup</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STARTUP\startup_stm32f10x_md.s</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Common\HAL\STM32F10x\STARTUP\system_stm32f10x.c</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\src\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\readme.txt</name>
  </file>
</project>



# IAR project sensor-node.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT=1; __FPU_USED=1; _DLIB_FILE_DESCRIPTOR=1; __ICCARM__; USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Common\HAL\STM32F10x\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\HAL\STM32F10x\STARTUP; ..\..\..\..\..\..\include; ..\..\..\..\..\..\components\finsh; ..\..\src; ..\..\..\Common\DRV; ..\..\..\Common\BSP; ..\..\..\Common\APL; ..\..\src\sensor; ..\..\src\finsh_cmd; ..\..\..\Common\DEV; ..\..\..\..\..\..\components\drivers\include; ..\..\..\Common\APL\apl_rf; ..\..\..\Common\APL\apl_rf\rf_if1; ..\..\..\Common\APL\apl_rf\rf_if2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sensor-a.hex
  ILINK.IlinkOutputFile: sensor-a.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../src/: main.c
    ../../: readme.txt
  group rtthread
    ../../src/: board.c rtconfig.h
  group rtthread/libcpu
    ../../../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group rtthread/module/finsh
    ../../../../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group rtthread/module/ringbuffer
    ../../../../../../components/drivers/src/: ringbuffer.c
  group rtthread/module/uip
    ../../../../../../components/net/uip/uip/: psock.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uip_timer.c uiplib.c
  group rtthread/module/uip/apps/dhcpc
    ../../../../../../components/net/uip/apps/dhcpc/: dhcpc.c
  group rtthread/module/uip/apps/resolv
    ../../../../../../components/net/uip/apps/resolv/: resolv.c
  group rtthread/module/uip/apps/smtp
    ../../../../../../components/net/uip/apps/smtp/: smtp-strings.c smtp.c
  group rtthread/module/uip/apps/telnetd
    ../../../../../../components/net/uip/apps/telnetd/: telnetd.c uip_shell.c
  group rtthread/module/uip/apps/webclient
    ../../../../../../components/net/uip/apps/webclient/: webclient-strings.c webclient.c
  group rtthread/module/uip/apps/webserver
    ../../../../../../components/net/uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd-fsdata.c httpd.c
  group rtthread/module/uip/uip_dev
    ../../../../../../components/net/uip/unix/: clock-arch.c tapdev.c uip-conf.h
  group rtthread/src
    ../../../../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group zonesion/app
    ../../src/finsh_cmd/: finsh_ex.c
  group zonesion/app/sensor
    ../../src/sensor/: sensor_node.c sensor_node.h sensor_thread.c
  group zonesion/app/sensor/sensor-a
    ../../src/sensor/sensor-a/: BH1750.c fbm320.c htu21d.c ld3320.c lis3dh.c MP-503.c sensor.c stadiometry.c
  group zonesion/common/APL
    ../../../Common/APL/apl_delay/: delay.c
  group zonesion/common/APL/apl_at
    ../../../Common/APL/apl_at/: at_app.c at_hw.c at_thread.c
  group zonesion/common/APL/apl_rf
    ../../../Common/APL/apl_rf/: rf_if_app.c rf_if_hw.c rf_thread.c
    ../../../Common/APL/apl_rf/zxbee/: zxbee.c
  group zonesion/common/APL/apl_rf/wifi
    ../../../Common/APL/apl_rf/wifi/: wifi_drv.c
  group zonesion/common/BSP
    ../../../Common/BSP/bsp_flash/: flash.c
    ../../../Common/BSP/bsp_i2c/: iic.c
  group zonesion/common/DEV
    ../../../Common/DEV/dev_serial/: serial.c
    ../../../Common/DEV/dev_uart/: usart.c
  group zonesion/common/DRV
    ../../../Common/DRV/drv_led/: fml_led.c
    ../../../Common/DRV/drv_relay/: relay.c
  group zonesion/common/LIB/stm32f10x
    ../../../../Common/HAL/STM32F10x/STARTUP/: system_stm32f10x.c
  group zonesion/common/LIB/stm32f10x/cmsis
    ../../../../Common/HAL/STM32F10x/CMSIS/CM3/CoreSupport/: core_cm3.c
  group zonesion/common/LIB/stm32f10x/fwlib
    ../../../../Common/HAL/STM32F10x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group zonesion/common/LIB/stm32f10x/startup
    ../../../../Common/HAL/STM32F10x/STARTUP/: startup_stm32f10x_md.s
